# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf.exe --bin --output .\build\keil\Obj\rtthread.bin .\build\keil\Obj\rt-thread.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARM_LIBC
  c misc: --no-multibyte-chars
  c include: ..\libraries\HAL_Drivers;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\components\drivers\include;applications;..\..\..\components\libc\compilers\common\include;..\libraries\HAL_Drivers\config;LCD7inch;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\poll;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\stdio;analog;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\drivers\spi;..\..\..\components\libc\posix\ipc;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;board\CubeMX_Config\Inc;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;.;board;json;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\components\finsh;..\libraries\HAL_Drivers\drv_flash;board\ports;modbus;w5500;ctrlConfig;FatFs;sdio
  memory RVCT4: ROM 0x8020000 size 0xd0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Analog
    analog/: adc.c analogTempHum.c
  group Applications
    applications/: W5500Task.c NetJsonDataSendTask.c NetJsonDataRecTask.c test_hardware.c main.c 7inchLCDTask.c NetJsonDataUpTask.c
    ./applications/: autoCtrlTask.c wdtTask.c sdRTCTask.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_adc.c drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Json
    json/: cJSON.c utf_8.c dataPhrase.c
    ./json/: registHeart.c didoCfg.c history.c logCtrl.c ota.c rebootSave.c sensorEvent.c sensorTHCfg.c sensorTimecfg.c dataPack.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group LCD7inch
    LCD7inch/: 7inchRegist.c
    ./LCD7inch/: lcdDispAutoCtrl.c lcdDispModbus.c lcdKeyEvent.c lcdSwitchCtrl.c lcdInputCfg.c lcdOutputCfg .c lcdDispAna.c lcdDispTHCfg.c lcdCoverCtrl.c ringbuf.c lcdFangChenJiang.c lcdFangWaiPo.c lcdGas.c lcdHuanLiu.c lcdJingGai.c lcdJuFang.c lcdLieFengYi.c lcdShuiWei.c lcdWenShiDu.c lcdDispChoose.c lcdUtcTime.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Modbus
    modbus/: modbus.c uartReconf.c rs485TempHum.c rs485CO.c rs485ThreeAxis.c rs485Circula.c rs485PressSettl.c rs485O2.c crc.c rs485WaterLev.c stm32Flash.c digConv.c rs485CH4.c rs485H2S.c rs485PartDischag.c
    ./modbus/: modbusConfig.c analogConfig.c rs485CrackMeter.c rs485Cover.c
    ./LCD7inch/: readme.c
  group W5500
    w5500/: socket.c tcp_demo.c utility.c w5500_conf.c loopback.c w5500.c dhcp.c
  group CtrlConfig
    ./ctrlConfig/: autoCtrl.c digInput.c digOutput.c threshold.c
  group SDIO
    ./sdio/: bsp_sdio_sd.c sdioRW.c sdFangChenJiang.c sdFangWaiPo.c sdHuanliu.c sdioRW.h sdJiaWan.c sdJingGai.c sdJuFang.c sdLieFengYi.c sdLiuHuaQing.c sdShuiWei.c sdWenShiDu.c sdYangQi.c sdYiYangHuaTan.c
  group FATFS
    ./FatFs/: diskio.c ff.c ff_gen_drv.c sd_diskio_dma.c cc936.c
    ./FatFs/option/: syscall.c
